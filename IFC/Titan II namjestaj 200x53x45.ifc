Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-07-20T13:37:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 20 13:37:48 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{56FE7831-0759-4712-AE91-285D8A85C669}\ifc * Database version: 5507 * Database creation date: Tue Jul 20 13:37:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 20 13:37:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 20 13:37:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: 200x53x45, Titan II 160-200 namjestaj_R18 :200x53x45:389399
In: Level 1
Material: AQ_Antique rose, AQ_Astone_white(1), AQ_Astone_white
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Pset_DistributionFlowElementCommon - Reference: Titan II 160-200 namjestaj_R18 :200x53x45
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 5.78969 m2; Volume: 0.0830004 m3
Identity Data - Mark: 22
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Titan II 160-200 namjestaj_R18 : 200x53x45; Family and Type: Titan II 160-200 namjestaj_R18 : 200x53x45; Type: Titan II 160-200 namjestaj_R18 : 200x53x45; Type Id: Titan II 160-200 namjestaj_R18 : 200x53x45
Phasing - Phase Created: New Construction
Dimensions(Type) - Otvor za pipu: 500 mm; Sirina: 1000 mm; Sirina ormara: 1000 mm; Sirina umivaonika: 1003 mm; Ukupna sirina: 2000 mm
Identity Data(Type) - Boja: Acryl bijela sjajna, acryl crna sjajna, crna mat protiv otisaka, lava, dijamant siva, kamen siva, chicago beton svijetli, chicago beton, halifax hrast bijeli, halifax hrast natur, halifax hrast tabak, cascina pine, hrast sherman sivi, antique rose; Izradio: Intelika d.o.o.; Manufacturer: Aquaestil; Materijal: Astone, akril, MDF; Model: TITAN II; Mogućnost ugradnje: na zid; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Sifon: Ø46; Type Name: 200x53x45; Web adresa: https://www.aquaestil.hr/hr/proizvodi/titan-premium-linija/kupaonski-namjestaj-titan/12-.html
Materials and Finishes(Type) - Materijal fronte vrata i ladica: AQ_Antique rose; Materijal konstrukcije: AQ_Astone_white; Materijal umivaonika: AQ_Astone_white(1)
Other(Type) - Category: Plumbing Fixtures; Family Name: Titan II 160-200 namjestaj_R18
